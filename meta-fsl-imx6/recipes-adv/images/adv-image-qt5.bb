DESCRIPTION = "Freescale Image - Adds Qt5"
LICENSE = "MIT"

require recipes-adv/images/adv-rootfs-main.bb

IMAGE_FSTYPES = "tar.bz2 ext4 sdcard"

